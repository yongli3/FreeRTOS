# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM32L152_EVAL; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: system_and_ST_code; system_and_ST_code\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; system_and_ST_code\CMSIS\CM3\CoreSupport; system_and_ST_code\STM32L1xx_StdPeriph_Driver\inc; system_and_ST_code\STM32L152_EVAL; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; system_and_ST_code\CMSIS\CM3\DeviceSupport\ST\STM32L1xx
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: system_and_ST_code\stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c ParTest.c serial.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c
    system_and_ST_code/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_spi.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Standard_Demo_Code
    ../Common/Minimal/: comtest.c dynamic.c flash.c GenQTest.c
  group System_and_ST_Code
    system_and_ST_code/: startup_stm32l1xx_md.s stm32l1xx_it.c system_stm32l1xx.c
  group System_and_ST_Code/Eval_Board_Library
    system_and_ST_code/STM32L152_EVAL/: stm32l152_eval.c stm32l152_eval_lcd.c
  group System_and_ST_Code/Peripheral_Library
    system_and_ST_code/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
